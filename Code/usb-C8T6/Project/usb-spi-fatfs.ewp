# IAR project usb-spi-fatfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\Libraries\CMSIS\CM3\CoreSupport; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Mass_Storage\inc; ..\STM32_USB-FS-Device_Driver\inc; ..\User; ..\User\bsp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: usb-spi-fatfs.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp
    ../../4-usb-spi-fatfs/User/bsp/: bsp_led.c bsp_led.h bsp_spi_flash.c bsp_spi_flash.h bsp_usart.c bsp_usart.h
  group CMSIS
    ../../4-usb-spi-fatfs/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../4-usb-spi-fatfs/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MassStorage
    ../../4-usb-spi-fatfs/Mass_Storage/src/: fsmc_nand.c hw_config.c mass_mal.c memory.c nand_if.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group startUp
    ../../4-usb-spi-fatfs/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group stdPeriphDriver
    ../../4-usb-spi-fatfs/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group USB_FS_Device_Driver
    ../../4-usb-spi-fatfs/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group user
    ../../4-usb-spi-fatfs/User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
